options:
  parameters:
    author: vitor
    generate_options: qt_gui
    id: modulacao_Sigma_Delta
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_sinal
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: freq_sinal
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '2'
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '1'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]'
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_sub_xx_0, '0']
- [blocks_add_const_vxx_0, '0', fir_filter_xxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_integrate_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_sub_xx_0, '0', blocks_integrate_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [fir_filter_xxx_0, '0', blocks_sub_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
